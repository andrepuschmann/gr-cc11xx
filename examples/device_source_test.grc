options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '800'
    stop: 200e3
    value: 50e3
  states: {}
- name: decim
  id: variable_qtgui_range
  parameters:
    label: decim
    rangeType: int
    start: '0'
    step: '10'
    stop: '1000'
    value: '20'
  states: {}
- name: demod_gain
  id: variable_qtgui_range
  parameters:
    label: demod gain
    start: '0'
    step: '800'
    stop: '100'
    value: '0.4'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc
    start: 800.6e6
    step: '600'
    stop: 921.6e6
    value: 868.29e6
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: fs
    start: 50e3
    step: '800'
    stop: 2500e3
    value: 1000e3
  states: {}
- name: gain_mu
  id: variable_qtgui_range
  parameters:
    label: gain_mu
    start: '0'
    step: '800'
    stop: '100'
    value: '0.175'
  states: {}
- name: gain_omega
  id: variable_qtgui_range
  parameters:
    label: gain_omega
    start: '0.001'
    step: '1'
    stop: '0.02'
    value: '0.0076'
  states: {}
- name: mag_gain
  id: variable_qtgui_range
  parameters:
    label: mag_gain
    start: '0'
    step: '800'
    stop: '30'
    value: '4'
  states: {}
- name: mu
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0.5'
  states: {}
- name: omega
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '800'
    stop: '100'
    value: '5'
  states: {}
- name: scale
  id: variable_qtgui_range
  parameters:
    label: scale
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: squelch_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: squelch alpha
    start: '0'
    step: '800'
    stop: '1'
    value: '0.5'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: squelch threshold
    start: '-90'
    step: '1'
    stop: '10'
    value: '-10'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demod_gain
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: squelch_alpha
    threshold: squelch_threshold
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: scale
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mag_gain
    type: float
  states: {}
- name: cc11xx_cc11xx_deframer_bb_0
  id: cc11xx_cc11xx_deframer_bb
  parameters:
    has_crc: 'True'
    has_whitening: 'True'
    preamble_bytes: '4'
    sync1: '0xe9'
    sync2: '0xca'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: gain_omega
    mu: mu
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010101010101010101010101010'
    tagname: preamble
    threshold: '0'
    type: byte
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: decim
    gain: '1'
    samp_rate: fs
    type: fir_filter_ccf
    width: cutoff/2
    win: window.WIN_HAMMING
  states: {}
- name: nb
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    num_tabs: '3'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: localhost
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    freq0: fc
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: fs
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '1024'
    gui_hint: nb@0
    name: '"FFT Plot"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: nb@1:0,1,1,1
    name: '"sync"'
    size: '1024'
    srate: fs/decim
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: nb@1:0,0,2,1
    name: '"Scope Plot - fm demod"'
    nconnections: '2'
    size: '1024'
    srate: fs/decim
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: '15'
    freq0: fc
    gain0: '10'
    gain_mode0: '0'
    if_gain0: '20'
    sample_rate: fs
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '1']
- [cc11xx_cc11xx_deframer_bb_0, out, network_socket_pdu_0, pdus]
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', cc11xx_cc11xx_deframer_bb_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
